# Keil uVision project LetGrow.uvprojx, settings and files
target LetGrow (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\PWM;..\HARDWARE\LCD;..\HARDWARE\SHT11;..\HARDWARE\PUMP;..\HARDWARE\DHT11;..\HARDWARE\WATERSENSOR;..\HARDWARE\BH1750;..\HARDWARE\BATTERY;..\HARDWARE\WIFI;..\HARDWARE\SHT20;..\HARDWARE\WS2812B;..\HARDWARE\RTC;..\HARDWARE\EXTI;..\HARDWARE\IWDG
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/SHT11/: sht11.c
    ../HARDWARE/PUMP/: pump.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/WATERSENSOR/: waterSensor.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/BATTERY/: battery.c
    ../HARDWARE/WIFI/: wifi.c
    ../HARDWARE/SHT20/: sht2x.c
    ../HARDWARE/WS2812B/: WS2812B.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IWDG/: iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_iwdg.c
  group README
    ../: README.TXT
  group LCD
    ../HARDWARE/LCD/: GUI.c Lcd_Driver.c QDTFT_demo.c
